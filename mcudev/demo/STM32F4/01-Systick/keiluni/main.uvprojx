# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MCU_STM32F4x
  c include: ..\..\..\..\..\..\SVGN\unisym\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group
    ./: main.cpp
  group Library Unisym
    ../../../../../../SVGN/_bin/mcu/: ustm32f4.lib
  group Library Standard
    ../../: startup_stm32f407xx.keil.s
