# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: _MCU_STM32H7x
  c include: M:\her\SVGN\unisym\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Group User
    ./: main.cpp
    M:/her/SVGN/_bin/mcu/: ustm32h7.lib
    ../../../devsrc/: OLED.cpp
    M:/her/SVGN/unisym/lib/cpp/Device/: IIC.cpp Video.cpp
  group Group Syst
    ../: startup_stm32h743xx.s
    ../../../driver/: ustm32h7.lib
