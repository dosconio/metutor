# Keil uVision project main.uvprojx, settings and files
target Target Main (6190000::V6.19::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F103xE, _MCU_STM32F1x
  c include: ..\..\..\..\..\..\SVGN\unisym\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group
    ./: main.cpp
  group Library Unisym
    ../../../../../../SVGN/_bin/mcu/: ustm32f1.lib
  group Library Standard
    ../../: startup_stm32f103xe.keil.s
